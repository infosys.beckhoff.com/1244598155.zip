TYPE E_ComState :
(
	INIT := 0,
	IDLE,
	CONNECT,
	DATATRANSFER,
	CLOSESOCKET,
	STOPDATATRANSFER
);
END_TYPE
